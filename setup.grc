options:
  parameters:
    author: Diego Neves
    description: Implementation of a signal generator
    generate_options: qt_gui
    id: SG
    output_language: python
    title: SG
  states: {}

blocks:
- name: SDR_1
  id: variable
  parameters:
    value: '"0000000000000000a06063c82535465f"'
  states: {}
- name: SDR_2
  id: variable
  parameters:
    value: '"000000000000000057b068dc22214f63"'
  states: {}
- name: auxiliar_filename
  id: variable
  parameters:
    value: '"test.txt"'
  states: {}
- name: filename_config
  id: variable
  parameters:
    value: my_mod.set_filenames(full_path, auxiliar_filename, raw_result_filename)
  states: {}
- name: freq
  id: variable
  parameters:
    value: my_mod.sweeper(fun_probe)
  states: {}
- name: frequency_config
  id: variable
  parameters:
    value: my_mod.set_frequency(frequency_start, frequency_stop, frequency_step)
  states: {}
- name: frequency_start
  id: variable
  parameters:
    value: 2.18e9
  states: {}
- name: frequency_step
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: frequency_stop
  id: variable
  parameters:
    value: 2.74e9
  states: {}
- name: full_path
  id: variable
  parameters:
    value: '"/home/diego/Downloads/hack_aut/hack_both/"'
  states: {}
- name: fun_probe
  id: variable_function_probe
  parameters:
    block_id: prob_block
    function_name: level
    poll_rate: '1'
    value: '1'
  states: {}
- name: qtgui_levelgauge_0
  id: qtgui_levelgauge
  parameters:
    isVertical: 'False'
    label: Frequency
    maximum: frequency_stop/1e6
    minimum: frequency_start/1e6
    showValue: 'True'
    type: real
    value: freq/1e6
  states: {}
- name: raw_result_filename
  id: variable
  parameters:
    value: '"result.txt"'
  states: {}
- name: receiver_SDR
  id: variable
  parameters:
    value: '2'
  states: {}
- name: receiver_config
  id: variable
  parameters:
    value: my_mod.set_receiver_serial_number(SDR_1, SDR_2, receiver_SDR)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: my_mod
  id: epy_module
  parameters:
    source_code: "def set_frequency(f_0, f_1, step):\n\tglobal f, f0, f1, df\n\tdf = step\n\tf0 = f_0\n\tf1 = f_1\n\tf = f_0 - step\n\treturn f_0\n\ndef set_receiver_serial_number(sf_1, sf_2, sf_id):\n\tglobal serial_number\n\tif sf_id == 1:\n\t\tserial_number = sf_1\n\telif sf_id == 2:\n\t\tserial_number = sf_2\n\treturn serial_number\n\ndef set_filenames(full_path, aux_name, result_name):\n\tglobal filename, result_filename\n\tfilename = full_path + aux_name\n\tresult_filename = full_path + result_name\t\n\treturn \"Done\"\n\ndef sweeper(prob_lvl):\n\tglobal f, f1, df, f0\n\n\tread_receptor(f)\n\tif prob_lvl:\n\t\tf += df\n\t\n\tif f >= f1:\n\t\tf = f0\n\t\t\n\treturn f\n\t\ndef read_receptor(f):\n\tglobal serial_number\n\timport os\n\n\tlow_frequency = int(f/1e6) - 10\n\thigh_frequency = int(f/1e6) + 10\n\tnumber_of_sweeps = 3\n\n\tfile_name = \"/home/diego/Downloads/hack_aut/hack_both/test.txt\"\n\tcommand = f'hackrf_sweep -f {low_frequency}:{high_frequency} -N {number_of_sweeps} -d {serial_number} -r {file_name}' \n\n\tos.system(command)\n\n\tmargin = 3e6\n\tanalyzer_file = open(\"/home/diego/Downloads/hack_aut/hack_both/test.txt\", \"r\")\n\tresults = analyzer_file.readlines()\n\n\tresult_file = open(\"/home/diego/Downloads/hack_aut/hack_both/result.txt\", \"a\")\n\tfor line in results:\n\t\tline = line.split(', ')\n\t\tlf = int(line[2])\n\t\tdf = int(float(line[4]))\n\n\t\tfor i in range(5):\n\t\t\tresult_file.write(str(lf + i*df) + \", \" + str(float(line[6 + i])) + \"\\n\")\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\t\n"
  states: {}
- name: prob_block
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', prob_block, '0']
- [analog_sig_source_x_0_1, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
